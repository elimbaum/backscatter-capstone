options:
  parameters:
    author: ebaum
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: damp
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.2'
    stop: '5'
    value: '1'
  states: {}
- name: enable_rx
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 1,4,1,1
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: filter_samp_rate
  id: variable
  parameters:
    value: 30e3
  states: {}
- name: freq_offset
  id: variable_qtgui_entry
  parameters:
    label: Freq Offset (Hz)
    type: real
    value: '-200'
  states: {state: disabled}
- name: freq_offset_coarse
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-60'
    step: '1'
    stop: '0'
    value: '-20'
  states: {}
- name: loop_bw
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.005'
    stop: '0.1'
    value: '0.045'
  states: {}
- name: moving_avg_len
  id: variable
  parameters:
    value: int(filter_samp_rate/10)
  states: {}
- name: pulse_width_hz
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,3,1,1
    label: pulse width (hz)
    type: int
    value: '4000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,2,1,1
    label: RX gain (dB)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '76'
    value: '45'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: scatter_center_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,2,1,1
    label: Scatter Freq (Hz)
    type: real
    value: '150942.76'
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(filter_samp_rate/symbol_rate)
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: ted_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.1'
    stop: '4'
    value: '1'
  states: {state: disabled}
- name: ted_gain
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '1'
  states: {}
- name: tone_freq
  id: variable
  parameters:
    value: tone_freq_khz * 1e3
  states: {}
- name: tone_freq_khz
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,1,1,1
    label: Tone Freq (kHz)
    type: real
    value: '100'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: TX gain (dB)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '89'
    value: '60'
  states: {}
- name: tx_samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: tone_freq
    offset: '0'
    phase: '0'
    samp_rate: tx_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-(tone_freq + scatter_center_freq + freq_offset)'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_offset_coarse
    offset: '0'
    phase: '0'
    samp_rate: filter_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_2
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_imag_0_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /Users/ebaum/Documents/capstone/iq/ask-tuned-30k.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    comment: calculate RE bias
    length: moving_avg_len
    max_iter: '4000'
    scale: 1/moving_avg_len
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    comment: calculate IM bias
    length: moving_avg_len
    max_iter: '4000'
    scale: 1/moving_avg_len
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: enable_rx
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_4
  id: blocks_multiply_const_vxx
  parameters:
    const: '2000'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_source_1
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_null_source_2
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_1
  id: blocks_repeat
  parameters:
    interp: '5'
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: filter_samp_rate
    type: complex
  states: {}
- name: digital_binary_slicer_fb_1
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: digital_binary_slicer_fb_2
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: damp
    loop_bw: loop_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '5'
    ted_gain: ted_gain
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: pulse_width_hz
    decim: int(samp_rate/filter_samp_rate)
    gain: '0.1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: pulse_width_hz * 0.5
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: '6'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    nconnections: '2'
    size: '128'
    type: complex
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: filter_samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_3
  id: qtgui_freq_sink_x
  parameters:
    bw: filter_samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '256'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '3'
    size: '1024'
    srate: filter_samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '3'
    size: '128'
    srate: filter_samp_rate
    tr_chan: '2'
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_4
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: center_freq
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: tx_samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: center_freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_2, '0', blocks_multiply_xx_1, '1']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_2, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_2, '2']
- [blocks_complex_to_imag_0, '0', qtgui_time_sink_x_3, '1']
- [blocks_complex_to_imag_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_repeat_1, '0']
- [blocks_complex_to_mag_1, '0', qtgui_time_sink_x_3, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_3, '0']
- [blocks_complex_to_real_1, '0', blocks_moving_average_xx_0, '0']
- [blocks_copy_0, '0', blocks_complex_to_imag_0, '0']
- [blocks_copy_0, '0', blocks_complex_to_mag_1, '0']
- [blocks_copy_0, '0', blocks_complex_to_real_0, '0']
- [blocks_copy_0, '0', mmse_resampler_xx_0, '0']
- [blocks_copy_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_copy_0, '0', qtgui_freq_sink_x_3, '1']
- [blocks_file_source_1, '0', blocks_throttle_0, '0']
- [blocks_float_to_complex_0, '0', blocks_sub_xx_0, '1']
- [blocks_moving_average_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_2, '1']
- [blocks_moving_average_xx_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_vxx_4, '0', blocks_complex_to_imag_0_0, '0']
- [blocks_multiply_const_vxx_4, '0', blocks_complex_to_real_1, '0']
- [blocks_multiply_const_vxx_4, '0', blocks_copy_0, '0']
- [blocks_multiply_const_vxx_4, '0', blocks_sub_xx_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_1, '0', blocks_multiply_const_vxx_4, '0']
- [blocks_multiply_xx_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_null_source_1, '0', qtgui_time_sink_x_3, '1']
- [blocks_null_source_1, '0', qtgui_time_sink_x_3, '2']
- [blocks_null_source_2, '0', qtgui_const_sink_x_0, '1']
- [blocks_repeat_1, '0', qtgui_time_sink_x_3, '2']
- [blocks_sub_xx_0, '0', blocks_copy_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_1, '0']
- [digital_binary_slicer_fb_2, '0', blocks_char_to_float_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0, '0', analog_agc_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_3, '0']
- [mmse_resampler_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
