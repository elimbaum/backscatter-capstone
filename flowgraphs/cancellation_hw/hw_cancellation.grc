options:
  parameters:
    author: ebaum
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amp_comp
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,2,1,1
    label: Amplitude Comp
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '2'
    value: '0.026'
  states: {}
- name: baseband_freq
  id: variable
  parameters:
    value: carrier_freq - center_freq
  states: {}
- name: bs_freq_offset
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: carrier_freq_mhz * 1e6
  states: {}
- name: carrier_freq_mhz
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,1,1,1
    label: Center Freq (MHz)
    type: real
    value: '915.1'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,1,1,1
    label: Frequency Offset
    orient: Qt.Horizontal
    start: '-10'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    orient: Qt.Vertical
    start: '0'
    step: '1'
    stop: '60'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: sample_delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,2,1,1
    label: Sample Delay
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: int(samp_rate / baseband_freq)
    value: '0'
  states: {}
- name: transmit_enable
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 1,2,1,1
    'true': '1'
    type: int
    value: 'True'
  states: {}
- name: tx_power
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '20'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: transmit_enable
    comment: TX waveform
    freq: baseband_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: cancellation waveform
    freq: baseband_freq + freq_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: flip it
    const: '-amp_comp'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: slight offset to make viewing easier
    const: '0.8'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    alpha3: '1'
    average: '0.2'
    bw: samp_rate
    color1: '"red"'
    color2: '"blue"'
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '1024'
    label1: Received Signal
    label2: Transmitted Signal
    label3: Compensated Signal
    nconnections: '3'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: Received
    label2: Sum
    label3: Cancellation
    nconnections: '3'
    size: '256'
    srate: samp_rate
    tr_chan: '2'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    int_max: '-30'
    type: complex
    update_time: '0.02'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: center_freq
    dev_args: '""'
    gain0: tx_power
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: center_freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: carrier_display
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: carrier_display
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', virtual_sink_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_real_0_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_real_0_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_freq_sink_x_0, '2']
- [uhd_usrp_source_0, '0', blocks_add_xx_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_real_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '1']

metadata:
  file_format: 1
